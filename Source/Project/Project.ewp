# IAR project Project.ewp, settings and files
configuration Board (ARM)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; MAIN_BOARD_PRJ; FIRMWARE_NON_BOOT_SOURCE
  ICCARM.CCIncludePath2: ; ..\APP\; ..\APP\RF_V2\; ..\APP\Uart_Debug\; ..\APP\Utilities\; ..\APP\PCCommunicate\; ..\APP\Extension Comm\; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc\; ..\..\Utilities\; ..\..\Utilities\Eeprom\; ..\..\Utilities\HardwareModule
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Utilities\FreeRTOS_v7.1.1\
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: MainBoard.out
  ILINK.IlinkIcfFile: icfFile\stm32f103x8_FWNonBoot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ./: main.c
  group App/App Driver/Utilites
    ../APP/Utilities/: Utilities.c
  group Core MCU & Peripheral
    icfFile/: stm32f103x8_FWNonBoot.icf
  group Core MCU & Peripheral/STM32F103x8
    ./: stm32f10x_it.c
  group Core MCU & Peripheral/STM32F103x8/CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Core MCU & Peripheral/STM32F103x8/STM32F1xx_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HW Driver
    ../../Utilities/HardwareModule/Board/: board.c board.h
    ../../Utilities/HardwareModule/Board/IO/: IO.c IO.h
    ../../Utilities/HardwareModule/Board/serial_debug/: serial_debug.c serial_debug.h
  group HW Driver/Fls
    ../../Utilities/FlashRW/: FlashRW.c FlashRW.h
  group HW Driver/GSM
    ../../Utilities/HardwareModule/Board/GSM_Thinh/: GSM_adapt.h GSM_app.c GSM_app.h GSM_drv.c GSM_drv.h string_user.c string_user.h
    ../../Utilities/HardwareModule/Board/SIM900/: SIM900.c SIM900.h
  group HW Driver/HardwareModule
    ../../Utilities/HardwareModule/: HardwareProfile.h
    ../../Utilities/: MemoryMap.h ToolSetting.h
  group HW Driver/serial_com
    ../../Utilities/serial_com/: serial_cbk.h serial_com.c serial_com.h serial_com_adapt.h
    ../../Utilities/MCU_Library/uart/: uart.c uart_cfg.c uart_cfg.h uart_IRQ.c uart_pub.h
  group HW Driver/serial_com/serial_com_reaction
    ../../Utilities/serial_com/serial_com_reaction/: serial_com_reaction.c serial_com_reaction.h
  group TASK
    ../../Utilities/HardwareModule/Board/Task/: Task.c Task.h
